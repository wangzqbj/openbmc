RDEPENDS_${PN}-inventory_append_fp5280g2 = "phosphor-cooling-type openpower-occ-control"
