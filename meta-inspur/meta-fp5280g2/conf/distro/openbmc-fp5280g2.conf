## meta-inspur/meta-fp5280g2/conf/distro/openbmc-fp5280g2.conf
```bitbake
require conf/distro/openbmc-openpower.conf
require conf/distro/include/phosphor-asppednic-user-mac2.inc
```
